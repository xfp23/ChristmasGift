# Keil uVision project ChristmasGift.uvprojx, settings and files
target ChristmasGift (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ChristmasGift +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Middleware;../Components/lvgl/examples;../Components/lvgl/src;../Components/lvgl;../Components;../Components/MicroMem;../Components/MicroNTC;../Components/MicroOS;../Components/MicroMem/include;../Components/MicroNTC/include;../Components/MicroOS/include;../ChipDriver;../ChipDriver/oled;../OSAL;../UserAPP;../OSAL/include;../OSAL/src;../Middleware/MgrLvgl;../Middleware/MgrNtc;..\Components\lvgl\examples\porting
  memory RVCT4: ROM 0x8000000 size 0xfa00
  memory RVCT9: RAM 0x20000000 size 0x4e20
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c iwdg.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Components
    ../Components/MicroMem/src/: MicroMem.c
    ../Components/MicroNTC/src/: ntc.c
    ../Components/MicroOS/src/: MicroOS.c MicroOSQueue.c
  group Middleware
    ../Middleware/: Middleware.c
    ../Middleware/MgrLvgl/: MgrLvgl.c
    ../Middleware/MgrNtc/: MgrNtc.c
  group ChipDriver
    ../ChipDriver/oled/: oled.c
  group OSAL
    ../OSAL/: OSAL.c
    ../OSAL/src/: OSAL_Event.c OSAL_MsgEvent.c OSAL_OSTimer.c OSAL_Task.c
  group UserApp
    ../UserAPP/: UserApp.c
  group Lvgl
    ../Components/lvgl/: lv_conf.h
    ../Components/lvgl/examples/porting/: lv_port_disp.c lv_port_fs.c lv_port_indev.c lv_port_lcd_stm32.c
    ../Components/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
    ../Components/lvgl/src/display/: lv_display.c
    ../Components/lvgl/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c
    ../Components/lvgl/src/draw/nema_gfx/: lv_draw_nema_gfx.c lv_draw_nema_gfx_arc.c lv_draw_nema_gfx_border.c lv_draw_nema_gfx_fill.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_stm32_hal.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx_utils.c lv_nema_gfx_path.c
    ../Components/lvgl/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_osa.c lv_pxp_utils.c
    ../Components/lvgl/src/draw/nxp/vglite/: lv_draw_buf_vglite.c lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_border.c lv_draw_vglite_fill.c lv_draw_vglite_img.c lv_draw_vglite_label.c lv_draw_vglite_layer.c lv_draw_vglite_line.c lv_draw_vglite_triangle.c lv_vglite_buf.c lv_vglite_matrix.c lv_vglite_path.c lv_vglite_utils.c
    ../Components/lvgl/src/draw/opengles/: lv_draw_opengles.c
    ../Components/lvgl/src/draw/renesas/dave2d/: lv_draw_dave2d.c lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c
    ../Components/lvgl/src/draw/sdl/: lv_draw_sdl.c
    ../Components/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../Components/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb888.c
    ../Components/lvgl/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
    ../Components/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../Components/lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_14_cjk.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Components/lvgl/src/indev/: lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ../Components/lvgl/src/layouts/flex/: lv_flex.c
    ../Components/lvgl/src/layouts/grid/: lv_grid.c
    ../Components/lvgl/src/layouts/: lv_layout.c
    ../Components/lvgl/src/libs/barcode/: code128.c lv_barcode.c
    ../Components/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ../Components/lvgl/src/libs/bmp/: lv_bmp.c
    ../Components/lvgl/src/libs/expat/: xmlparse.c xmlrole.c xmltok.c xmltok_impl.c xmltok_ns.c
    ../Components/lvgl/src/libs/ffmpeg/: lv_ffmpeg.c
    ../Components/lvgl/src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    ../Components/lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Components/lvgl/src/libs/gif/: gifdec.c lv_gif.c
    ../Components/lvgl/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    ../Components/lvgl/src/libs/libpng/: lv_libpng.c
    ../Components/lvgl/src/libs/lodepng/: lodepng.c lv_lodepng.c
    ../Components/lvgl/src/libs/lz4/: lz4.c
    ../Components/lvgl/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Components/lvgl/src/libs/rle/: lv_rle.c
    ../Components/lvgl/src/libs/rlottie/: lv_rlottie.c
    ../Components/lvgl/src/libs/svg/: lv_svg.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c
    ../Components/lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c
    ../Components/lvgl/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
    ../Components/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../Components/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c lv_cache_lru_rb.c lv_image_cache.c lv_image_header_cache.c
    ../Components/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_mqx.c lv_os.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
    ../Components/lvgl/src/others/file_explorer/: lv_file_explorer.c
    ../Components/lvgl/src/others/font_manager/: lv_font_manager.c lv_font_manager_recycle.c lv_font_manager_utils.c
    ../Components/lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Components/lvgl/src/others/gridnav/: lv_gridnav.c
    ../Components/lvgl/src/others/ime/: lv_ime_pinyin.c
    ../Components/lvgl/src/others/imgfont/: lv_imgfont.c
    ../Components/lvgl/src/others/monkey/: lv_monkey.c
    ../Components/lvgl/src/others/observer/: lv_observer.c
    ../Components/lvgl/src/others/snapshot/: lv_snapshot.c
    ../Components/lvgl/src/others/sysmon/: lv_sysmon.c
    ../Components/lvgl/src/others/vg_lite_tvg/: vg_lite_matrix.c
    ../Components/lvgl/src/others/xml/: lv_xml.c lv_xml_base_types.c lv_xml_component.c lv_xml_parser.c lv_xml_style.c lv_xml_utils.c lv_xml_widget.c
    ../Components/lvgl/src/others/xml/parsers/: lv_xml_button_parser.c lv_xml_chart_parser.c lv_xml_image_parser.c lv_xml_label_parser.c lv_xml_obj_parser.c lv_xml_slider_parser.c lv_xml_tabview_parser.c
    ../Components/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../Components/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../Components/lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../Components/lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../Components/lvgl/src/stdlib/: lv_mem.c
    ../Components/lvgl/src/themes/default/: lv_theme_default.c
    ../Components/lvgl/src/themes/mono/: lv_theme_mono.c
    ../Components/lvgl/src/themes/simple/: lv_theme_simple.c
    ../Components/lvgl/src/themes/: lv_theme.c
    ../Components/lvgl/src/tick/: lv_tick.c
    ../Components/lvgl/src/widgets/animimage/: lv_animimage.c
    ../Components/lvgl/src/widgets/arc/: lv_arc.c
    ../Components/lvgl/src/widgets/bar/: lv_bar.c
    ../Components/lvgl/src/widgets/button/: lv_button.c
    ../Components/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../Components/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Components/lvgl/src/widgets/canvas/: lv_canvas.c
    ../Components/lvgl/src/widgets/chart/: lv_chart.c
    ../Components/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../Components/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../Components/lvgl/src/widgets/image/: lv_image.c
    ../Components/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../Components/lvgl/src/widgets/label/: lv_label.c
    ../Components/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../Components/lvgl/src/widgets/led/: lv_led.c
    ../Components/lvgl/src/widgets/line/: lv_line.c
    ../Components/lvgl/src/widgets/list/: lv_list.c
    ../Components/lvgl/src/widgets/lottie/: lv_lottie.c
    ../Components/lvgl/src/widgets/menu/: lv_menu.c
    ../Components/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../Components/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../Components/lvgl/src/widgets/property/: lv_animimage_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_slider_properties.c lv_style_properties.c lv_textarea_properties.c
    ../Components/lvgl/src/widgets/roller/: lv_roller.c
    ../Components/lvgl/src/widgets/scale/: lv_scale.c
    ../Components/lvgl/src/widgets/slider/: lv_slider.c
    ../Components/lvgl/src/widgets/span/: lv_span.c
    ../Components/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../Components/lvgl/src/widgets/spinner/: lv_spinner.c
    ../Components/lvgl/src/widgets/switch/: lv_switch.c
    ../Components/lvgl/src/widgets/table/: lv_table.c
    ../Components/lvgl/src/widgets/tabview/: lv_tabview.c
    ../Components/lvgl/src/widgets/textarea/: lv_textarea.c
    ../Components/lvgl/src/widgets/tileview/: lv_tileview.c
    ../Components/lvgl/src/widgets/win/: lv_win.c
    ../Components/lvgl/src/: lv_init.c
software components: CMSIS:CORE 5.5.0
